# IAR project tusb5052.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (8051)
  as the first configuration, except:
  group (top)
    ./: bootcode.c bootcode.h delay.h header.c header.h i2c.c i2c.h io51.h tusb5052.h types.h usb.h
