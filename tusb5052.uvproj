# Keil uVision project tusb5052.uvproj, settings and files
target Target 1 (MCS-51)
  device: TUSB5052 Texas Instruments
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0xF800-0xFFFF) CLOCK(4800000)
  output: tusb5052
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: bootcode.c i2c.c bootcode.h delay.h header.h i2c.h types.h usb.h
